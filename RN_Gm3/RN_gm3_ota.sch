v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -160 -50 -160 -40 {lab=#net1}
N -100 -40 -30 -40 {lab=#net1}
N -100 -40 -100 0 {lab=#net1}
N -160 -70 -150 -70 {lab=GND}
N -30 -70 -20 -70 {lab=GND}
N -100 30 -90 30 {lab=GND}
N -100 60 -100 70 {lab=GND}
N -90 30 -90 70 {lab=GND}
N -100 70 -90 70 {lab=GND}
N -30 -40 -20 -40 {lab=#net1}
N -170 -160 -160 -160 {lab=Vdd}
N -170 -190 -170 -160 {lab=Vdd}
N -170 -190 -160 -190 {lab=Vdd}
N -20 -160 -10 -160 {lab=Vdd}
N -10 -190 -10 -160 {lab=Vdd}
N -20 -190 -10 -190 {lab=Vdd}
N -160 -120 -160 -100 {lab=#net2}
N -20 -120 -20 -100 {lab=Vout}
N -160 -210 -160 -190 {lab=Vdd}
N -90 -210 -20 -210 {lab=Vdd}
N -20 -210 -20 -190 {lab=Vdd}
N -110 -160 -60 -160 {lab=#net2}
N -110 -160 -110 -120 {lab=#net2}
N -160 -120 -110 -120 {lab=#net2}
N 20 -70 50 -70 {lab=Vin-}
N -20 -120 30 -120 {lab=Vout}
N -90 -250 -90 -210 {lab=Vdd}
N -240 -70 -200 -70 {lab=Vin+}
N -190 30 -140 30 {lab=#net3}
N -150 -40 -100 -40 {lab=#net1}
N -160 -40 -150 -40 {lab=#net1}
N -120 -160 -110 -160 {lab=#net2}
N -160 -130 -160 -120 {lab=#net2}
N -20 -130 -20 -120 {lab=Vout}
N -160 -210 -90 -210 {lab=Vdd}
N 30 -120 90 -120 {lab=Vout}
N -290 30 -190 30 {lab=#net3}
N -1230 40 -1230 50 {lab=#net3}
N -1230 -10 -1230 40 {lab=#net3}
N -1320 20 -1230 20 {lab=#net3}
N -160 -290 -160 -250 {lab=Vdd}
N -160 -330 -160 -290 {lab=Vdd}
N -160 -330 -70 -330 {lab=Vdd}
N -70 -330 -70 -320 {lab=Vdd}
N -300 -70 -280 -70 {lab=Vin+}
N -330 -250 -90 -250 {lab=Vdd}
N -300 -250 -300 -150 {lab=Vdd}
N -280 -70 -240 -70 {lab=Vin+}
N -380 30 -290 30 {lab=#net3}
N -1150 90 -980 90 {lab=#net4}
N -1230 50 -1230 60 {lab=#net3}
N -1230 300 -1150 300 {lab=#net5}
N -1150 270 -1150 300 {lab=#net5}
N -1310 -30 -1310 -10 {lab=#net6}
N -1460 -10 -1310 -10 {lab=#net6}
N -1310 -210 -1230 -210 {lab=#net7}
N -1230 -210 -1230 -190 {lab=#net7}
N -650 -260 -330 -260 {lab=Vdd}
N -330 -260 -330 -250 {lab=Vdd}
N -1460 -260 -650 -260 {lab=Vdd}
N -1460 -260 -1460 -250 {lab=Vdd}
N -1230 30 -380 30 {lab=#net3}
N -640 -70 -620 -70 {lab=Vin+}
N -620 -70 -300 -70 {lab=Vin+}
N -1030 -70 -640 -70 {lab=Vin+}
N -1030 -70 -1030 -50 {lab=Vin+}
N -1030 10 -930 10 {lab=#net8}
N -930 -50 -880 -50 {lab=#net9}
N -880 10 -800 10 {lab=#net10}
N -800 -50 -720 -50 {lab=#net11}
N -720 10 -640 10 {lab=#net12}
N -640 -50 -540 -50 {lab=#net13}
N -540 10 -460 10 {lab=#net14}
N -460 -50 -380 -50 {lab=#net15}
N -380 10 -300 10 {lab=#net16}
N -390 -90 -300 -90 {lab=#net17}
N -480 -150 -390 -150 {lab=#net18}
N -570 -90 -480 -90 {lab=#net19}
N -650 -150 -570 -150 {lab=#net20}
N -740 -90 -650 -90 {lab=#net21}
N -830 -150 -740 -150 {lab=#net22}
N -920 -90 -830 -90 {lab=#net23}
N -990 -150 -920 -150 {lab=#net24}
N -1080 -150 -990 -90 {lab=#net25}
N -1100 -70 -1080 -90 {lab=Vin+}
N -1100 -70 -1030 -70 {lab=Vin+}
N 180 -70 220 -70 {lab=Vin-}
N 260 -70 280 -70 {lab=Vin-}
N 220 -70 260 -70 {lab=Vin-}
N 600 -70 620 -70 {lab=Vin-}
N 280 -70 600 -70 {lab=Vin-}
N 620 -70 1010 -70 {lab=Vin-}
N 1010 -70 1010 -50 {lab=Vin-}
N 910 10 1010 10 {lab=#net26}
N 860 -50 910 -50 {lab=#net27}
N 780 10 860 10 {lab=#net28}
N 700 -50 780 -50 {lab=#net29}
N 620 10 700 10 {lab=#net30}
N 520 -50 620 -50 {lab=#net31}
N 440 10 520 10 {lab=#net32}
N 360 -50 440 -50 {lab=#net33}
N 280 10 360 10 {lab=#net34}
N 280 -90 370 -90 {lab=#net35}
N 370 -150 460 -150 {lab=#net36}
N 460 -90 550 -90 {lab=#net37}
N 550 -150 630 -150 {lab=#net38}
N 630 -90 720 -90 {lab=#net39}
N 720 -150 810 -150 {lab=#net40}
N 810 -90 900 -90 {lab=#net41}
N 900 -150 970 -150 {lab=#net42}
N 970 -90 1060 -150 {lab=#net43}
N 1060 -90 1080 -70 {lab=Vin-}
N 1010 -70 1080 -70 {lab=Vin-}
N 50 -70 180 -70 {lab=Vin-}
N -310 -50 -300 -50 {lab=GND}
N -20 -210 280 -210 {lab=Vdd}
N 280 -210 280 -150 {lab=Vdd}
C {symbols/nfet_05v0.sym} -120 30 0 0 {name=M3
L=1.2u
W=16u
nf=8
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/nfet_05v0.sym} -180 -70 0 0 {name=M2
L=1u
W=7.5u
nf=4
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/pfet_05v0.sym} -140 -160 0 1 {name=M5
L=2u
W=17u
nf=10
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/ppolyf_u_3k.sym} -1230 -40 0 0 {name=R1
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_3k.sym} -980 240 0 0 {name=R2
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {symbols/cap_nmos_06v0.sym} -1350 20 1 0 {name=C3
W=60e-6
L=10e-6
model=cap_nmos_06v0
spiceprefix=X
m=6}
C {ipin.sym} -160 -290 0 0 {name=p6 lab=Vdd}
C {symbols/cap_nmos_06v0.sym} -70 -290 0 0 {name=C4
W=60e-6
L=10e-6
model=cap_nmos_06v0
spiceprefix=X
m=6}
C {lab_pin.sym} -70 -260 0 1 {name=p20 sig_type=std_logic lab=GND}
C {lab_pin.sym} -1250 -40 0 0 {name=p2 sig_type=std_logic lab=GND}
C {lab_pin.sym} -1000 240 0 0 {name=p3 sig_type=std_logic lab=GND}
C {lab_pin.sym} -1380 20 0 0 {name=p4 sig_type=std_logic lab=GND}
C {lab_pin.sym} -980 270 0 0 {name=p7 sig_type=std_logic lab=GND}
C {lab_pin.sym} -30 -70 0 0 {name=p15 sig_type=std_logic lab=GND}
C {lab_pin.sym} -150 -70 0 1 {name=p16 sig_type=std_logic lab=GND}
C {ipin.sym} -90 70 0 1 {name=p1 lab=GND
}
C {opin.sym} 90 -120 0 0 {name=p9 lab=Vout
}
C {symbols/nfet_05v0.sym} 0 -70 0 1 {name=M1
L=1u
W=7.5u
nf=4
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_05v0
spiceprefix=X
}
C {symbols/ppolyf_u_3k.sym} -300 -120 0 0 {name=R3
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_3k.sym} -300 -20 0 0 {name=R4
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -310 -50 0 0 {name=p5 sig_type=std_logic lab=GND}
C {lab_pin.sym} -320 -120 0 0 {name=p8 sig_type=std_logic lab=GND}
C {lab_pin.sym} -320 -20 0 0 {name=p10 sig_type=std_logic lab=GND}
C {ipin.sym} -1100 -70 0 0 {name=p11 lab=Vin+}
C {ipin.sym} 1080 -70 0 1 {name=p12 lab=Vin-}
C {symbols/pfet_05v0.sym} -40 -160 0 0 {name=M4
L=2u
W=17u
nf=10
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_05v0
spiceprefix=X
}
C {symbols/ppolyf_u_3k.sym} -980 180 0 0 {name=R7
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1000 180 0 0 {name=p19 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -980 120 0 0 {name=R8
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1000 120 0 0 {name=p21 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1150 240 0 0 {name=R9
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1170 240 0 0 {name=p22 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1150 180 0 0 {name=R10
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1170 180 0 0 {name=p23 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1150 120 0 0 {name=R11
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1170 120 0 0 {name=p24 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1230 90 2 0 {name=R12
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1210 90 2 0 {name=p25 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1230 150 2 0 {name=R13
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1210 150 2 0 {name=p26 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1230 210 2 0 {name=R14
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1210 210 2 0 {name=p27 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1230 270 0 0 {name=R15
W=2e-6
L=30e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1250 270 0 0 {name=p28 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1230 -100 0 0 {name=R16
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1250 -100 0 0 {name=p29 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1230 -160 0 0 {name=R17
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1250 -160 0 0 {name=p30 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1310 -180 2 0 {name=R18
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1290 -180 2 0 {name=p31 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1310 -120 2 0 {name=R19
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1290 -120 2 0 {name=p32 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1310 -60 2 0 {name=R20
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1290 -60 2 0 {name=p33 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1460 -100 0 0 {name=R21
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1480 -100 0 0 {name=p34 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1460 -160 0 0 {name=R22
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1480 -160 0 0 {name=p35 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1460 -220 0 0 {name=R23
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1480 -220 0 0 {name=p36 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1460 -40 0 0 {name=R24
W=2e-6
L=100e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1480 -40 0 0 {name=p37 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -380 -20 2 0 {name=R25
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -360 -20 2 0 {name=p38 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -460 -20 0 0 {name=R26
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -480 -20 0 0 {name=p39 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -540 -20 2 0 {name=R27
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -520 -20 2 0 {name=p40 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -640 -20 0 0 {name=R28
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -660 -20 0 0 {name=p41 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -720 -20 2 0 {name=R29
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -700 -20 2 0 {name=p42 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -800 -20 0 0 {name=R30
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -820 -20 0 0 {name=p43 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -880 -20 2 0 {name=R31
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -860 -20 2 0 {name=p44 sig_type=std_logic lab=GND}
C {lab_pin.sym} -910 -20 2 0 {name=p45 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -930 -20 2 0 {name=R32
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1050 -20 0 0 {name=p46 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1030 -20 0 0 {name=R33
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_3k.sym} -390 -120 0 0 {name=R34
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -410 -120 0 0 {name=p47 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -480 -120 0 0 {name=R35
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -500 -120 0 0 {name=p48 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -570 -120 0 0 {name=R36
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -590 -120 0 0 {name=p49 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -650 -120 0 0 {name=R37
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -670 -120 0 0 {name=p50 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -740 -120 0 0 {name=R38
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -760 -120 0 0 {name=p51 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -830 -120 0 0 {name=R39
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -850 -120 0 0 {name=p52 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -920 -120 0 0 {name=R40
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -940 -120 0 0 {name=p53 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -990 -120 0 0 {name=R41
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1010 -120 0 0 {name=p54 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} -1080 -120 0 0 {name=R42
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} -1100 -120 0 0 {name=p55 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 280 -120 0 1 {name=R5
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_3k.sym} 280 -20 0 1 {name=R6
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 280 -50 0 1 {name=p13 sig_type=std_logic lab=GND}
C {lab_pin.sym} 300 -120 0 1 {name=p14 sig_type=std_logic lab=GND}
C {lab_pin.sym} 300 -20 0 1 {name=p17 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 360 -20 2 1 {name=R43
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 340 -20 2 1 {name=p56 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 440 -20 0 1 {name=R44
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 460 -20 0 1 {name=p57 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 520 -20 2 1 {name=R45
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 500 -20 2 1 {name=p58 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 620 -20 0 1 {name=R46
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 640 -20 0 1 {name=p59 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 700 -20 2 1 {name=R47
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 680 -20 2 1 {name=p60 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 780 -20 0 1 {name=R48
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 800 -20 0 1 {name=p61 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 860 -20 2 1 {name=R49
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 840 -20 2 1 {name=p62 sig_type=std_logic lab=GND}
C {lab_pin.sym} 890 -20 2 1 {name=p63 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 910 -20 2 1 {name=R50
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 1030 -20 0 1 {name=p64 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 1010 -20 0 1 {name=R51
W=2e-6
L=600e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_3k.sym} 370 -120 0 1 {name=R52
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 390 -120 0 1 {name=p65 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 460 -120 0 1 {name=R53
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 480 -120 0 1 {name=p66 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 550 -120 0 1 {name=R54
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 570 -120 0 1 {name=p67 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 630 -120 0 1 {name=R55
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 650 -120 0 1 {name=p68 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 720 -120 0 1 {name=R56
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 740 -120 0 1 {name=p69 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 810 -120 0 1 {name=R57
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 830 -120 0 1 {name=p70 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 900 -120 0 1 {name=R58
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 920 -120 0 1 {name=p71 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 970 -120 0 1 {name=R59
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 990 -120 0 1 {name=p72 sig_type=std_logic lab=GND}
C {symbols/ppolyf_u_3k.sym} 1060 -120 0 1 {name=R60
W=2e-6
L=400e-6
model=ppolyf_u_3k
spiceprefix=X
m=1}
C {lab_pin.sym} 1080 -120 0 1 {name=p73 sig_type=std_logic lab=GND}
