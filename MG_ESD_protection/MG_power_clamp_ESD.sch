v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -280 -100 200 -100 {lab=Vdd}
N -280 100 200 100 {lab=GND}
N -160 70 -160 100 {lab=GND}
N 0 -100 0 -80 {lab=Vdd}
N 0 80 0 100 {lab=GND}
N 160 -100 160 -30 {lab=Vdd}
N 160 30 160 100 {lab=GND}
N -0 -50 90 -50 {lab=Vdd}
N 90 -100 90 -50 {lab=Vdd}
N -0 50 90 50 {lab=GND}
N 90 50 90 100 {lab=GND}
N 200 100 240 100 {lab=GND}
N -0 -20 0 20 {lab=clamp}
N -40 -50 -40 50 {lab=#net1}
N -50 -0 -40 -0 {lab=#net1}
N -160 -0 -50 0 {lab=#net1}
N -500 100 -280 100 {lab=GND}
N -670 100 -650 100 {lab=GND}
N -520 -100 -280 -100 {lab=Vdd}
N -670 -100 -520 -100 {lab=Vdd}
N -650 100 -500 100 {lab=GND}
N 320 -100 320 -30 {lab=Vdd}
N 320 30 320 100 {lab=GND}
N 160 0 200 -0 {lab=GND}
N 200 -0 200 100 {lab=GND}
N 320 -0 360 -0 {lab=GND}
N 360 -0 360 100 {lab=GND}
N 460 -100 460 -30 {lab=Vdd}
N 460 30 460 100 {lab=GND}
N 500 100 540 100 {lab=GND}
N 620 -100 620 -30 {lab=Vdd}
N 620 30 620 100 {lab=GND}
N 460 0 500 0 {lab=GND}
N 500 0 500 100 {lab=GND}
N 620 0 660 0 {lab=GND}
N 660 0 660 100 {lab=GND}
N 780 -100 780 -30 {lab=Vdd}
N 780 30 780 100 {lab=GND}
N 820 100 860 100 {lab=GND}
N 940 -100 940 -30 {lab=Vdd}
N 940 30 940 100 {lab=GND}
N 780 0 820 0 {lab=GND}
N 820 0 820 100 {lab=GND}
N 940 0 980 0 {lab=GND}
N 980 0 980 100 {lab=GND}
N 1080 -100 1080 -30 {lab=Vdd}
N 1080 30 1080 100 {lab=GND}
N 1120 100 1160 100 {lab=GND}
N 1240 -100 1240 -30 {lab=Vdd}
N 1240 30 1240 100 {lab=GND}
N 1080 0 1120 0 {lab=GND}
N 1120 0 1120 100 {lab=GND}
N 1240 0 1280 0 {lab=GND}
N 1280 0 1280 100 {lab=GND}
N 1410 -100 1410 -30 {lab=Vdd}
N 1410 30 1410 100 {lab=GND}
N 1450 100 1490 100 {lab=GND}
N 1570 -100 1570 -30 {lab=Vdd}
N 1570 30 1570 100 {lab=GND}
N 1410 0 1450 0 {lab=GND}
N 1450 0 1450 100 {lab=GND}
N 1570 0 1610 0 {lab=GND}
N 1610 0 1610 100 {lab=GND}
N 200 -100 320 -100 {lab=Vdd}
N 320 -100 460 -100 {lab=Vdd}
N 460 -100 620 -100 {lab=Vdd}
N 620 -100 780 -100 {lab=Vdd}
N 780 -100 940 -100 {lab=Vdd}
N 940 -100 1080 -100 {lab=Vdd}
N 1080 -100 1240 -100 {lab=Vdd}
N 1240 -100 1410 -100 {lab=Vdd}
N 1410 -100 1570 -100 {lab=Vdd}
N 1570 100 1610 100 {lab=GND}
N 1490 100 1570 100 {lab=GND}
N 1410 100 1450 100 {lab=GND}
N 1280 100 1410 100 {lab=GND}
N 1240 100 1280 100 {lab=GND}
N 1160 100 1240 100 {lab=GND}
N 1080 100 1120 100 {lab=GND}
N 980 100 1080 100 {lab=GND}
N 940 100 980 100 {lab=GND}
N 860 100 940 100 {lab=GND}
N 240 100 320 100 {lab=GND}
N 320 100 360 100 {lab=GND}
N 360 100 460 100 {lab=GND}
N 460 100 500 100 {lab=GND}
N 540 100 620 100 {lab=GND}
N 620 100 660 100 {lab=GND}
N 660 100 780 100 {lab=GND}
N 780 100 820 100 {lab=GND}
N -160 -0 -160 10 {lab=#net1}
N -680 0 -160 0 {lab=#net1}
N -680 -40 -680 -0 {lab=#net1}
N -650 -20 -110 -20 {lab=GND}
N -650 -20 -650 100 {lab=GND}
N -80 -100 -80 -40 {lab=Vdd}
N -200 -40 -140 -40 {lab=Vdd}
N -140 -40 -80 -40 {lab=Vdd}
C {devices/ipin.sym} -670 -100 0 0 {name=p1 lab=Vdd}
C {devices/ipin.sym} -670 100 0 0 {name=p2 lab=GND}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/pfet_05v0.sym} -20 -50 0 0 {name=MM_p1 W=12u L=0.7u m=1 nf=6}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} -20 50 0 0 {name=MM_n1 W=4.8u L=0.7u m=1 nf=2}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 140 0 0 0 {name=MM_clamp W=10u L=0.7u nf=4}
C {symbols/cap_mim_2f0fF.sym} -160 40 0 0 {name=C1
W=20e-6
L=20e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {lab_pin.sym} 0 0 0 1 {name=p3 sig_type=std_logic lab=clamp}
C {lab_pin.sym} 120 0 0 0 {name=p4 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 300 0 0 0 {name=MM_clamp1 W=10u L=0.7u nf=4}
C {lab_pin.sym} 280 0 0 0 {name=p5 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 440 0 0 0 {name=MM_clamp2 W=10u L=0.7u nf=4}
C {lab_pin.sym} 420 0 0 0 {name=p6 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 600 0 0 0 {name=MM_clamp3 W=10u L=0.7u nf=4}
C {lab_pin.sym} 580 0 0 0 {name=p7 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 760 0 0 0 {name=MM_clamp4 W=10u L=0.7u nf=4}
C {lab_pin.sym} 740 0 0 0 {name=p8 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 920 0 0 0 {name=MM_clamp5 W=10u L=0.7u nf=4}
C {lab_pin.sym} 900 0 0 0 {name=p9 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 1060 0 0 0 {name=MM_clamp6 W=10u L=0.7u nf=4}
C {lab_pin.sym} 1040 0 0 0 {name=p10 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 1220 0 0 0 {name=MM_clamp7 W=10u L=0.7u nf=4}
C {lab_pin.sym} 1200 0 0 0 {name=p11 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 1390 0 0 0 {name=MM_clamp8 W=10u L=0.7u nf=4}
C {lab_pin.sym} 1370 0 0 0 {name=p12 sig_type=std_logic lab=clamp}
C {/foss/pdks/ciel/gf180mcu/versions/7b70722e33c03fcb5dabcf4d479fb0822d9251c9/gf180mcuD/libs.tech/xschem/symbols/nfet_05v0.sym} 1550 0 0 0 {name=MM_clamp9 W=10u L=0.7u nf=4}
C {lab_pin.sym} 1530 0 0 0 {name=p13 sig_type=std_logic lab=clamp}
C {symbols/ppolyf_u_1k_6p0.sym} -590 -40 3 0 {name=R2
W=1e-6
L=4e-5
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k_6p0.sym} -650 -40 3 0 {name=R1
W=1e-6
L=4e-5
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k_6p0.sym} -470 -40 3 0 {name=R3
W=1e-6
L=4e-5
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k_6p0.sym} -530 -40 3 0 {name=R4
W=1e-6
L=4e-5
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k_6p0.sym} -350 -40 3 0 {name=R5
W=1e-6
L=4e-5
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k_6p0.sym} -410 -40 3 0 {name=R6
W=1e-6
L=4e-5
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k_6p0.sym} -230 -40 3 0 {name=R7
W=1e-6
L=4e-5
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1}
C {symbols/ppolyf_u_1k_6p0.sym} -290 -40 3 0 {name=R8
W=1e-6
L=4e-5
model=ppolyf_u_1k_6p0
spiceprefix=X
m=1}
