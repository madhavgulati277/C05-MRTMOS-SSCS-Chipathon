v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {MG_lowpass_filter.sym} 100 10 0 0 {name=x1}
